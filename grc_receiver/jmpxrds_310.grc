options:
  parameters:
    author: Nick Kossifidis
    category: Custom
    description: This flow can be used for debugging JMPXRDS
    generate_options: qt_gui
    id: jmpxrds_rx
    output_language: python
    realtime_scheduling: '1'
    thread_safe_setters: '1'
    title: JMPXRDS Receiver (based on gr_rds)
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: mpx_samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: TODO ?
    value: '44000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '-20'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: Noise
  id: audio_sink
  parameters:
    device_name: jack
    ok_to_block: 'False'
    samp_rate: mpx_samp_rate
  states: {state: disabled}
- name: Tones
  id: audio_sink
  parameters:
    device_name: jack
    ok_to_block: 'False'
    samp_rate: mpx_samp_rate
  states: {state: disabled}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.2'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: mpx_samp_rate
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: mpx_samp_rate
    tau: '50e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.2'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: mpx_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.2'
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: mpx_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '0.2'
    freq: '50'
    offset: '0'
    phase: '0'
    samp_rate: mpx_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: '0.2'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: mpx_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_4
  id: analog_sig_source_x
  parameters:
    amp: '0.2'
    freq: '5000'
    offset: '0'
    phase: '0'
    samp_rate: mpx_samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: L+R
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/jmpxrds_rtp_client.sock
    repeat: 'False'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(1.*(volume)/10)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(1.*(volume)/10)
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: L-R
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_mpsk_receiver_cc_0
  id: digital_mpsk_receiver_cc
  parameters:
    M: '2'
    fmax: '0.06'
    fmin: '-0.06'
    gain_mu: '0.05'
    gain_omega: '0.001'
    mu: '0.5'
    omega: mpx_samp_rate/4/2375.0
    omega_relative_limit: '0.005'
    theta: '0'
    w: 1*cmath.pi/100.0
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.low_pass(1.0,mpx_samp_rate,17e3,3e3,window.WIN_HAMMING)
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: '4'
    samp_rate: mpx_samp_rate
    taps: firdes.low_pass(1.0,mpx_samp_rate,2.4e3,2e3,window.WIN_HAMMING)
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '38000'
    decim: '1'
    samp_rate: mpx_samp_rate
    taps: firdes.low_pass(1.0,mpx_samp_rate,17e3,3e3,window.WIN_HAMMING)
    type: fcf
  states: {}
- name: gr_rds_decoder_0
  id: gr_rds_decoder
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: gr_rds_panel_0
  id: gr_rds_panel
  parameters:
    freq: '96700000'
  states: {}
- name: gr_rds_parser_0
  id: gr_rds_parser
  parameters:
    debug: 'False'
    log: 'False'
    pty_locale: '0'
    reset: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: R
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: L
  states: {}
- name: note_0_2
  id: note
  parameters:
    comment: |-
      TODO 
      rds blocks impl
    note: RDS
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: mpx_samp_rate
    fbw: '0.4'
    interp: audio_samp_rate
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: mpx_samp_rate
    fbw: '0.4'
    interp: audio_samp_rate
    taps: ''
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '1'
    ntaps: '100'
    samp_rate: mpx_samp_rate/4
    sym_rate: '2375'
    type: fir_filter_ccf
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', Noise, '0']
- [analog_fm_deemph_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_frequency_modulator_fc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_1, '4']
- [analog_sig_source_x_1, '0', blocks_add_xx_1, '2']
- [analog_sig_source_x_2, '0', blocks_add_xx_1, '3']
- [analog_sig_source_x_3, '0', blocks_add_xx_1, '0']
- [analog_sig_source_x_4, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0_0, '0']
- [blocks_add_xx_1, '0', Tones, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '1']
- [blocks_complex_to_real_0, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [blocks_complex_to_real_0_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_file_source_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_file_source_0, '0', fir_filter_xxx_1, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_2, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_diff_decoder_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_sub_xx_0, '0', analog_fm_deemph_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_keep_one_in_n_0, '0']
- [digital_diff_decoder_bb_0, '0', gr_rds_decoder_0, '0']
- [digital_mpsk_receiver_cc_0, '0', blocks_complex_to_real_0_0, '0']
- [digital_mpsk_receiver_cc_0, '0', qtgui_time_sink_x_0, '0']
- [fir_filter_xxx_1, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_1, '0', blocks_sub_xx_0, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_0_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', root_raised_cosine_filter_0, '0']
- [freq_xlating_fir_filter_xxx_2, '0', blocks_complex_to_real_0, '0']
- [gr_rds_decoder_0, out, gr_rds_parser_0, in]
- [gr_rds_parser_0, out, gr_rds_panel_0, in]
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '1']
- [root_raised_cosine_filter_0, '0', digital_mpsk_receiver_cc_0, '0']

metadata:
  file_format: 1
